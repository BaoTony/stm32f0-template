# Keil uVision project Demo.uvprojx, settings and files
target stm32f030 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F030C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Demo
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F030X8,USE_STDPERIPH_DRIVER
  c include: ..\APP\inc;..\Drivers\BSP\inc;..\Drivers\CMSIS\inc;..\Drivers\STM32F0xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group APP
    ../APP/src/: main.c stm32f0xx_it.c
  group BSP
    ../Drivers/BSP/src/: led.c
  group Core
    ../Drivers/CMSIS/src/: system_stm32f0xx.c
  group Startup
    ../Drivers/CMSIS/startup/: startup_stm32f030.s
  group FWLIB
    ../Drivers/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group ReadMe
    ../Doc/: ReadMe.txt
